# Keil uVision project evdk.uvproj, settings and files
target evdk ram (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: evdk +hex
  c flags: Optim=3 oTime=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F4XX, VECT_TAB_SRAM
  c include: .\inc;..\libraries\CMSIS\Include;..\libraries\STM32F4xx_StdPeriph_Driver\inc;..\libraries\CMSIS\ST\STM32F4xx\Include
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0x7000
  memory RVCT9: RAM 0x20007000 size 0x19000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group user
    ./src/: timer.c operators.c stm32f4xx_it.c VisionSet_project.c musicplayer.c
  group camera
    ./src/: camera.c camera_io.c dcmi.c sccb.c
  group main
    ./src/: led.c main.c mem_manager.c pc_interface.c programma.c
  group stm32f4-stdperiph_lib
    ./src/: motor.c
    ../libraries/STM32F4-Discovery_FW_V1.1.0/Utilities/STM32F4-Discovery/: stm32f4_discovery_audio_codec.c
    ../libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_spi.c stm32f4xx_dac.c
  group cmsis
    ./src/: system_stm32f4xx.c
  group startup
    ./startup/: startup_stm32f4xx.s
target evdk flash (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: as above
  output: evdk +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F4XX
  c include: .\inc;..\libraries\CMSIS\Include;..\libraries\STM32F4xx_StdPeriph_Driver\inc;..\libraries\CMSIS\ST\STM32F4xx\Include;..\libraries\STM32F4-Discovery_FW_V1.1.0\Utilities\STM32F4-Discovery
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
